# IAR project Accessed3.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152RE ST STM32L152RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32L152xE
  ICCARM.CCIncludePath2: ..\SRC\APP; ..\SRC\BSP; ..\SRC\UTIL; ..\SRC\Drivers\CMSIS; ..\SRC\Drivers\STM32L1xx_HAL_Driver\Inc; ..\SRC\Drivers\STM32L1xx_HAL_Driver\Src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Accessed3.srec
  ILINK.IlinkOutputFile: Accessed3.out
  ILINK.IlinkIcfFile: D:\MSC_local\DSP\Assignment3\PROJ\stm32l152xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32L152xE
  ICCARM.CCOptLevel: 3
  group APP
    ../SRC/APP/: main.c main.h Protocol.c Protocol.h startup_stm32l152xe.s stm32l1xx_it.c stm32l1xx_it.h system_stm32l1xx.c
  group BSP
    ../SRC/BSP/: ADC.c ADC.h board_conf.h clk.c clk.h LED.c LED.h Timer.c Timer.h Uart.c Uart.h
  group Drivers/CMSIS
    ../SRC/Drivers/CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h stm32l152xe.h stm32l1xx.h system_stm32l1xx.h
  group Drivers/STM32L1xx_HAL_Driver/Inc
    ../SRC/Drivers/STM32L1xx_HAL_Driver/Inc/: stm32l1xx_ll_adc.h stm32l1xx_ll_bus.h stm32l1xx_ll_comp.h stm32l1xx_ll_cortex.h stm32l1xx_ll_crc.h stm32l1xx_ll_dac.h stm32l1xx_ll_dma.h stm32l1xx_ll_exti.h stm32l1xx_ll_fsmc.h stm32l1xx_ll_gpio.h stm32l1xx_ll_i2c.h stm32l1xx_ll_iwdg.h stm32l1xx_ll_opamp.h stm32l1xx_ll_pwr.h stm32l1xx_ll_rcc.h stm32l1xx_ll_rtc.h stm32l1xx_ll_sdmmc.h stm32l1xx_ll_spi.h stm32l1xx_ll_system.h stm32l1xx_ll_tim.h stm32l1xx_ll_usart.h stm32l1xx_ll_utils.h stm32l1xx_ll_wwdg.h
  group Drivers/STM32L1xx_HAL_Driver/Src
    ../SRC/Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_ll_adc.c stm32l1xx_ll_comp.c stm32l1xx_ll_crc.c stm32l1xx_ll_dac.c stm32l1xx_ll_dma.c stm32l1xx_ll_exti.c stm32l1xx_ll_gpio.c stm32l1xx_ll_i2c.c stm32l1xx_ll_opamp.c stm32l1xx_ll_pwr.c stm32l1xx_ll_rcc.c stm32l1xx_ll_rtc.c stm32l1xx_ll_spi.c stm32l1xx_ll_tim.c stm32l1xx_ll_usart.c stm32l1xx_ll_utils.c
  group UTIL
    ../SRC/UTIL/: delay.c delay.h ring_buffer.c ring_buffer.h
